Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2019-06-18T12:04:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 18 12:04:06 2019 * Host: Piranha * Database: C:\Users\datBIM\AppData\Local\Temp\{F57B4F2B-E7D1-41D0-BED6-2572E3E3E5CA}\ifc * Database version: 5507 * Database creation date: Tue Jun 18 12:04:03 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 18 12:04:04 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 18 12:04:04 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 mm
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: 0001

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: Marqueur de niveau - Cercle: Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no

# IfcBuildingElementProxy: A SWITCH 4PORTS EPV, A SWITCH 4PORTS EPV:A SWITCH 4PORTS EPV:137502
In: Niveau 1
Type - Autre - Catégorie: Equipement électrique; datBIM.Classe electrique (Electrical class): 1; datBIM.Code datBIM entité: 4690009999; datBIM.Code produit SLAT (Id SlatEntityCode): 4690009999; datBIM.Conformite ATEX (ATEX compliance): Non (No); datBIM.Couleur dominante (Dominant color): Gris (Grey); datBIM.Courant maximal d'utilisation (Maximal output current): 0.6 A; datBIM.Description longue entité: <p> <img title="Switch 4 ports EPV.JPG" src="https://admin.datbim.com/media/mid/1/23380.jpg" alt="" width="115" height="239" data-idmedia="23380" /></p><p><em>Ref. : 4690009999<br /></em></p><p>Vidéosurveillance / Video protection.</p>; datBIM.Designation technique (Technical designation): A KIT PoE PASSIF; datBIM.Duree de la garantie (Length of warranty): 1 an; datBIM.Duree de vie previsionnelle (Expected life expectancy): 10 ans; datBIM.Fonction generique (Generic function): Injecteur POE passif (Passive POE injector); datBIM.Id: datBIM:384268; datBIM.Largeur (Wide): 154 mm; datBIM.Libellé entité: A SWITCH 4PORTS EPV; datBIM.Marque commerciale (Commercial brand): SLAT; datBIM.Matiere de l'enveloppe (Envelope material): Polycarbonate; datBIM.Nombre de sorties d'alimentation (Number of power supply outputs): 1; datBIM.Poids (Weight): 0.04; datBIM.Produit repartis dans plusieurs enveloppes (Product divided into several envelopes): Non (No); datBIM.Puissance (Output power): 30 W; datBIM.Qualification d'installateur : NF S 61-932 - Règles d’installation (Installer qualification : NF S 61-932 - Installation rules): Recommandé (Recommanded); datBIM.Qualification d'installateur : NF S 61-970 - Règles d'installation des systèmes de détection incendie (Installer qualification : Installation rules for fire detection systems): Recommandé (Recommanded); datBIM.Qualification d'installateur : R7 (Installer qualification : R7): Recommandé (Recommanded); datBIM.Qualification du mainteneur : Annexe B NF S 61-933 - SDI (Qualification of the maintainer : Appendix B NF S 61-933 - SDI): Recommandé (Recommanded); datBIM.Qualification du mainteneur : Annexe J NF S 61-933 Alimentation (Qualification of the maintainer : Appendix J NF S 61-933 Power supply): Recommandé (Recommanded); datBIM.Qualification du mainteneur : Annexe L NF S 61-933 Exploitant (Qualification of the maintainer : Appendix L NF S 61-933 Operator): Recommandé (Recommanded); datBIM.Rendement energetique (Energy efficiency): 0.999; datBIM.Site WEB du fournisseur: www.slat.com; datBIM.Substance visee par REACH_DEEE (Substance covered by REACH_DEEE): Non (No); datBIM.Temperature d'utilisation (Operating temperature): -40 à +85°C; datBIM.Tension nominale de sortie (Rated output voltage): 55 V; datBIM.Type de liaison (Type of link): Filaire (Wired); datBIM.Type d'installation (Mounting type): Rail DIN (DIN rail-mounted); Nom de la famille: A SWITCH 4PORTS EPV
Type - Données d'identification - Fabricant: SLAT; Nom du type: A SWITCH 4PORTS EPV
Pset_BuildingElementProxyCommon - Reference: A SWITCH 4PORTS EPV
Pset_ManufacturerTypeInformation - Manufacturer: SLAT
Autre - Famille: A SWITCH 4PORTS EPV: A SWITCH 4PORTS EPV; Famille et type: A SWITCH 4PORTS EPV: A SWITCH 4PORTS EPV; ID du type: A SWITCH 4PORTS EPV: A SWITCH 4PORTS EPV; Type: A SWITCH 4PORTS EPV: A SWITCH 4PORTS EPV
Contraintes - Décalage: 0 mm; Hôte: Niveau : Niveau 1; Niveau: Niveau: Niveau 1; Se déplace avec les éléments voisins: no
Cotes - Surface: 0.021075 m2; Volume: 0.000131307 m3
Données d'identification - Identifiant: 1
Electricité - Charges - Charge apparente - Phase A: 0 W; Charge apparente - Phase B: 0 W; Charge apparente - Phase C: 0 W; Charge totale connectée: 0 W; Demande de charge totale estimée: 0 W; Facteur de charge totale: 1
Phase de construction - Phase de création: Phase 1
